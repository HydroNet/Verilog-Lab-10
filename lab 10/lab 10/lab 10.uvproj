# Keil uVision project lab 10.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lab 10 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  link misc: --first=mystartup.o(RESET)
  group Source Group 1
    ./: mycode.s mystartup.s SWI_HANDLER.s lcd_subbs.s mydips.s
