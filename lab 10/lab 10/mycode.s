	GLOBAL SUBRTS
	GLOBAL BRANCHBACK
		AREA mycode, CODE, readonly
SUBRTS
PINSEL0	EQU 0XE002C000
IO0PIN	EQU 0XE0028000
IO0SET	EQU 0X4
IO0DIR	EQU 0X8
IO0CLR	EQU 0XC
LEDMASK EQU 0xFF00
CLOCK			EQU		12000000
DELAY10U		EQU		(CLOCK/400000)
	    MOV r2, #0
        LDR r3, =PINSEL0
        STR r2,[r3]
		LDR R3, =IO0PIN
		LDR R4, [r3,#IO0DIR]
        LDR R2,= 0xFF00
		ORR R4,R4,R2
        STR R4, [r3,#IO0DIR]
        MOV r2,    #0x0000FF00;turns LEDs off
        STR r2, [r3,#IO0SET]
	SWI #1
		LDR		r0, =DELAY10U
LOOP	SUBS	r0, r0, #1
		BNE		LOOP
	SWI #2
		LDR		r0, =DELAY10U
LOOP2	SUBS	r0, r0, #1
		BNE		LOOP2
BRANCHBACK
	SWI #3
STOP B STOP
	END 
		